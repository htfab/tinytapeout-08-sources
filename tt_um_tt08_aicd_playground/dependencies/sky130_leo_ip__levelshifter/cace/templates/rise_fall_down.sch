** sch_path: tt_um_tt08_aicd_playground/dependencies/sky130_leo_ip__levelshifter/cace/templates/rise_fall_down.sch
**.subckt rise_fall_down
x1 VDDOUT out in VGND sky130_leo_ip__levelshifter_down
V1 VDDIN GND CACE{vddin}
V2 VDDOUT GND CACE{vddout}
V3 VGND GND 0
C1 out VGND CACE{cl} m=1
V5 in VGND pulse 0 CACE{vddin} 0 100p 100p 10n 20n
**** begin user architecture code




.control
    * operating point
    *op
    *write tb.raw
    *set appendwrite

    * transient simulation
    options method=gear
    tran 1p 40n
    *save all
    *write tb.raw

    * measure parameters

    * get the peak-to-peak voltage
    meas TRAN range PP v(out)
    let ten=0.1*range
    let ninety=0.9*range

    print range ten ninety

    # rise and fall time
    meas TRAN rise_time TRIG v(out) VAL=ten    TD=0ns  RISE=1   TARG v(out) VAL=ninety TD=0ns
+  RISE=1
    meas TRAN fall_time TRIG v(out) VAL=ninety TD=5ns  FALL=1   TARG v(out) VAL=TEN    TD=5ns
+  FALL=1

    print rise_time fall_time

    echo $&rise_time $&fall_time > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc





.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends

* expanding   symbol:  sky130_leo_ip__levelshifter_down.sym # of pins=4
** sym_path: tt_um_tt08_aicd_playground/dependencies/sky130_leo_ip__levelshifter/xschem/sky130_leo_ip__levelshifter_down.sym
** sch_path: tt_um_tt08_aicd_playground/dependencies/sky130_leo_ip__levelshifter/xschem/sky130_leo_ip__levelshifter_down.sch
.subckt sky130_leo_ip__levelshifter_down VDDOUT OUT IN VGND
*.ipin IN
*.iopin VGND
*.opin OUT
*.iopin VDDOUT
XM3 OUT n VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2)
+ * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 /
+ W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 OUT n VDDOUT VDDOUT sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2)
+ * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 /
+ W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 n IN VDDOUT VDDOUT sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2)
+ * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 /
+ W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 n IN VGND VGND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2)
+ * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 /
+ W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND
.end
